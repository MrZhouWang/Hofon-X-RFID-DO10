# Keil uVision project X-M3P1O5.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: X-M3P1O5_V2_2_20151214 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../src/: eeprom.c led.c main.c uart.c process.c key.c
