# Keil uVision project RFID.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W1K16S STC
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: RFID2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC;..\SRC;..\PRO
  group Source Group 1
    ./: STARTUP.A51
  group SRC
    ../SRC/: MAIN.C RC522.C
  group INC
    ../INC/: MAIN.H MFRC522.H REG52.H STDIO.H
