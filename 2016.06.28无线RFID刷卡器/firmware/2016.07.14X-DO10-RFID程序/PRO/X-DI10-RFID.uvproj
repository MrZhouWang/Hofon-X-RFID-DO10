# Keil uVision project X-DI10-RFID.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: X-DI10-RFID07.11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC;..\PRO;..\SRC
  group Source Group 1
    ./: STARTUP.A51
  group INC
    ../INC/: eeprom.h key.h led.h main.h mytype.h process.h STC_NEW_8051.H uart.h include.h timer.h delay.h init.h common.h mrc522_api.h mrc522_hal.h led_display.h
  group SRC
    ../SRC/: crc.c eeprom.c key.c led.c main.c process.c uart.c timer.c delay.c init.c commom.c mrc522_api.c mrc522_hal.c led_display.c
  group RECORD
    ../RECORD/: readme.text
