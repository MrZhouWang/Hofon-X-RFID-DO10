# Keil uVision project TEST522.uvproj, settings and files
target 射频读写卡器 (MCS-51)
  device: STC15W1K16S STC
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: 12122 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 主程序
    ./: MAIN.C RC522.C
