# Keil uVision project RFID.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: RFID +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC;..\SRC;..\PRO
  group Source Group 1
    ./: STARTUP.A51
  group SRC
    ../SRC/: MAIN.C RC522.C
  group INC
    ../INC/: MFRC522.H INCLUDE.h MAIN.H REG52.H STDIO.H
